IMAGE_INSTALL:append = "hostapd kea"
